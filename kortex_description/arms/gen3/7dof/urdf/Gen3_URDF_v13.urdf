Commit message: Updating urdf file for controls, and updated controller nodes

File: kortex_description/arms/gen3/7dof/urdf/Gen3_URDF_v13.urdf (robot description, URDF)
Before this commit: robot GEN3_URDF_V12, 9 links, 8 joints
Links:
- link Bracelet_Link: mass 0.5006 -> 0.364
